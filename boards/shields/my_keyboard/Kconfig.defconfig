## boards/shields/my_keyboard/Kconfig.defconfig
```kconfig
# Copyright (c) 2021 The ZMK Contributors
# SPDX-License-Identifier: MIT



config ZMK_KEYBOARD_NAME
    default "my_keyboard"

endif
```
